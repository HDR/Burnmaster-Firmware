# Keil uVision project GDCartReader.uvprojx, settings and files
target Debug (5060960::V5.06 update 7 (build 960)::.\COM)
  device: GD32F103VC GigaDevice
  pack: GigaDevice.GD32F10x_DFP.2.0.3
  cpu: IRAM(0x20000000,0x00010000) IROM(0x0800C000,0x00034000) CPUTYPE("Cortex-M3") CLOCK(8000000) ELITTLE
  output: GDCartReader +hex
  AfterMake: $KARM\ARMCC\bin\fromelf.exe --bin --output=@L.bin !L
  c flags: Optim=1 uC99=1 wLevel=2
  c define: GD32F10X_HD,USE_STDPERIPH_DRIVER,__GD32F10X_FAMILY,__GD32F103_SUBFAMILY,ARM_MATH_CM3,__NO_FPU_ENABLE
  c include: .\;.\fatfs;.\GD32F10x\Device\Include;.\CMSIS_5\CMSIS\Core\Include
  asm include: as above
  memory RVCT4: ROM 0x800c000 size 0x34000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\GD32F103VC_APP.sct
  group Application
    ./: main.c Display.c Operate.c Common.c GB.c GBA.c GBM.c flashparam.c
    ./GD32F10x/Device/Source/: gd32f10x_usart.c
  group FatFs
    ./fatfs/: diskio.c ff.c ffsystem.c ffunicode.c sdcard.c
  group GD32 Drivers
    ./GD32F10x/Device/Source/: system_gd32f10x.c gd32f10x_gpio.c gd32f10x_rcu.c gd32f10x_i2c.c gd32f10x_sdio.c gd32f10x_dma.c gd32f10x_fmc.c
  group Startup
    ./: startup_gd32f103vc.s
